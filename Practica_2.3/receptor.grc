options:
  parameters:
    author: uis-e3t
    generate_options: qt_gui
    id: ConfiguracionUSRP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la señal Tx
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Tx
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
