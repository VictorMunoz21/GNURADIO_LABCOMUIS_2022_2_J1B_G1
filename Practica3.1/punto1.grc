options:
  parameters:
    author: UIS
    copyright: UIS
    generate_options: qt_gui
    id: punto1
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '300'
    step: '100'
    stop: '21000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficente de estabilidad Ka
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: EnvolventeComplejaJ1BG1_0
  id: EnvolventeComplejaJ1BG1
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Envolvente Compleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Envolvente Compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaJ1BG1_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaJ1BG1_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeComplejaJ1BG1_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaJ1BG1_0, '0']

metadata:
  file_format: 1
